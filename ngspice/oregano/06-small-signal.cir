******************************************************************************
*          Electronic circuit simulation file generated by gSpiceUI          *
*                        Version 1.2.87 (2020-09-18)                         *
******************************************************************************

********** Component Definitions **********

c2 2 0 1u
r1 1 2 1k
vin 1 0 dc 0 ac 1

********** NG-Spice Simulation Commands **********

.OPTIONS NOPAGE WIDTH=88
.PRINT TRAN V(1,0) V(1) V(2)
.TRAN 10.00m 100.00m 0.00m

.END
